# Keil uVision project rmmc.uvprojx, settings and files
target К1986ВЕ92QI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Milandr.MDR1986BExx.1.4.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rmmc
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;.\inc\usb
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    C:/Users/dell/Documents/Keil/RMMC/src/: adc.c flash.c hamming.c pid.c uart.c util.c
    ./: main.c
    ./src/usb/: bulk_transfer.c ccsbcs.c ctrl_transfer.c diskio.c ff.c ff_addons.c syscall.c usb_host.c
  group inc
    C:/Users/dell/Documents/Keil/RMMC/inc/: adc.h flash.h hamming.h pid.h uart.h util.h
    ./inc/usb/: bulk_transfer.h ctrl_transfer.h diskio.h ff.h ffconf.h integer.h types.h usb_host.h
software components: Device:Startup 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1, Drivers:SSP 1.3.1, Drivers:TIMER 1.3.1, Drivers:UART 1.3.1, Drivers:USB 1.3.1
